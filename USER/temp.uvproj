# Keil uVision project temp.uvproj, settings and files
target temp (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: temp +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,NO_PNG,
  c misc: --C99
  c include: ..\CORE;..\FWLIB\inc;..\HARDWARE\USART;..\USER;..\HARDWARE\delay;..\HARDWARE\sys;..\HARDWARE\LED;..\backend
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_exti.c
  group HARDWARE
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/sys/: sys.c
    ../HARDWARE/USART/: usart.c uart2.c led_hal.c led.c systick.c timer14.c timers.c
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group zint
    ../backend/: 2of5.c auspost.c codablock.c code.c code1.c code16k.c code49.c code128.c common.c composite.c dllversion.c dmatrix.c dotcode.c eci.c gridmtx.c gs1.c hanxin.c imail.c large.c library.c mailmark.c maxicode.c medical.c pdf417.c plessey.c postal.c qr.c raster.c reedsol.c render.c rss.c telepen.c upcean.c
